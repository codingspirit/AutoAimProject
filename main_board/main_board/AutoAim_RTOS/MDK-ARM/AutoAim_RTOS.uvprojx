# Keil uVision project AutoAim_RTOS.uvprojx, settings and files
target AutoAim_RTOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: AutoAim_RTOS
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;                            ../Drivers/STM32F4xx_HAL_Driver/Inc;                            ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                            ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                            ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                            ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;                            ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                            ../Middlewares/Third_Party/FreeRTOS/Source/include;                            ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                            ../Drivers/CMSIS/Include
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pcd.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim.c stm32f4xx_ll_usb.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ramfunc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c croutine.c queue.c timers.c list.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c usbd_cdc_if.c usbd_conf.c usbd_desc.c gpio.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_hal_msp.c freertos.c usb_device.c tim.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
software components: CMSIS:CORE 5.0.1
